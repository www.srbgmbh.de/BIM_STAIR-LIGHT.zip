Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-09-07T11:51:24+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativ-UI 23.0.11.19

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: STAIR-LIGHT-W:STAIR-LIGHT-W - 260 lm - Zentralbatterie, STAIR-LIGHT-W:STAIR-LIGHT-W - 260 lm - Zentralbatterie:2487275
In: Default
Type - Material: Weiß_1
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: STAIR-LIGHT-W - 260 lm - Zentralbatterie; sets with these values: 2
